<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\Nx_TCP_Echo_Client_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
